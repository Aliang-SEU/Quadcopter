# Keil uVision project Sizhou.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Sizhou +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\LIB\src;.\LIB\inc;.\USER;.\Src\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c
  group Control
    ./Src/src/: pwm.c rc.c control.c
  group Communication
    ./Src/src/: uart_communication.c
  group EEPROM
    ./Src/src/: EEPROM.c
  group BSP
    ./Src/src/: Attitude_Calc.c kalman.c
  group Src
    ./Src/src/: delay.c led.c Timer.c uart1.c mpu9250.c oled.c key.c
  group Lib
    ./LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTCODE
    ./CMSIS/startup/arm/: startup_stm32f10x_hd.s
